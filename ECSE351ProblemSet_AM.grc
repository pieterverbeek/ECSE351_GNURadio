options:
  parameters:
    generate_options: qt_gui
    id: ECSE351ProblemSet
    output_language: python
    title: Thresholding Demonstration
  states: {}

blocks:
- name: AM_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: f_carrier
  id: variable_qtgui_range
  parameters:
    start: '5000'
    step: '.1'
    stop: '15000'
    value: '10000'
  states: {}
- name: f_mod
  id: variable_qtgui_range
  parameters:
    start: '300'
    step: '100'
    stop: '2700'
    value: '1000'
  states: {}
- name: mod_index
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.1'
    stop: '1'
    value: '.5'
  states: {}
- name: relative_scale_dB
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5'
    stop: '60'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: mod_index
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: mod_index
    type: complex
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_3
  id: analog_const_source_x
  parameters:
    const: '.1'
    type: complex
  states: {}
- name: analog_const_source_x_3_0
  id: analog_const_source_x
  parameters:
    const: relative_scale_dB
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_mod
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {}
- name: dB_scaler
  id: blocks_embedded_python
  parameters:
    imports: |
      import numpy as np
      from gnuradio import gr
    code: |
      class blk(gr.sync_block):
          """
          Scale a complex stream by 10^(gain_dB/20)
          """
          def __init__(self, gain_dB=0.0):
              gr.sync_block.__init__(
                  self,
                  name="dB Scaler",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.set_gain(gain_dB)

          def set_gain(self, gain_D​B):
              # recompute linear gain from dB slider
              self.gain_lin = 10 ** (gain_D​B / 20.0)

          def work(self, input_items, output_items):
              out = output_items[0]
              # elementwise multiply by current gain
              out[:] = input_items[0] * self.gain_lin
              return len(out)
    gain_dB: relative_scale_dB
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_am_demod_cf_0, '0', qtgui_sink_x_0, '0']
- [analog_const_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_const_source_x_0_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_const_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_1_0, '0', blocks_add_xx_0_0, '1']
- [analog_const_source_x_3, '0', blocks_multiply_xx_2_0, '0']
- [analog_const_source_x_3_0, '0', dB_scaler, '0']
- [dB_scaler, '0', blocks_multiply_xx_2_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_1, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_1, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_xx_2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
